include gskinnerteam-flutter-wonderous-app-wonders_2.2.4.inc
# by default, running with release
RDEPENDS:append:${PN} = " flutter-engine-release"
