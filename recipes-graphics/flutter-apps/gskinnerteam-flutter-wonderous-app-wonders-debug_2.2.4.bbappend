S = "${WORKDIR}/git"

FLUTTER_APP_RUNTIME_MODES="debug"