inherit flutter-mode-release
require gskinnerteam-flutter-wonderous-app-wonders_2.2.4.inc
