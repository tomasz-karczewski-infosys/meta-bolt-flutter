inherit flutter-mode-debug
require gskinnerteam-flutter-wonderous-app-wonders_2.2.4.inc

