inherit flutter-mode-profile
require gskinnerteam-flutter-wonderous-app-wonders_2.2.4.inc
